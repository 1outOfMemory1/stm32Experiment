# Keil uVision project FatFS.uvprojx, settings and files
target FatFS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FatFS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\App;..\..\Board\Include;..\..\Chip\CMSIS;..\..\Chip\STM32F10x_StdPeriph_Driver\inc;..\..\App\MALLOC;..\..\App\FATFS\exfuns;..\..\App\FATFS\src;..\..\App\FATFS\src\option
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../../App/: main.c stm32f10x_it.c
  group Board
    ../../Board/Source/: BSP_Led.c BSP_UART.c BSP_SDCard.c BSP_Graphics.c BSP_ParallelBus.c BSP_TFTLCD.c sys.c
  group CMSIS
    ../../Chip/CMSIS/startup/: startup_stm32f10x_hd.s
    ../../Chip/CMSIS/: core_cm3.c system_stm32f10x.c
  group StdPeriph_Driver
    ../../Chip/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MALLOC
    ../../App/MALLOC/: malloc.c
  group FatFS
    ../../App/FATFS/src/: diskio.c ff.c
    ../../App/FATFS/exfuns/: exfuns.c fattester.c
    ../../App/FATFS/src/option/: cc936.c
  group Doc
    ../../Document/: Readme.txt
